# Keil uVision project Smart_Fish_Tank.uvprojx, settings and files
target Smart_Fish_Tank (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Smart_Fish_Tank +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,FPU_USED=1
  c include: ..\CORE;..\OBJ;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HALLIB\STM32F4xx_HAL_Driver\Inc;..\HARDWARE\LCD;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\SPI;..\HARDWARE\WKUP;..\HARDWARE\RTC;..\HARDWARE\TIMER;..\HARDWARE\USMART;..\HARDWARE\ADC;..\HARDWARE\SDIO;..\HARDWARE\SPI;..\HARDWARE\W25QXX;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\HARDWARE\TOUCH;..\HARDWARE\DS18B20;..\HARDWARE\HCSR04;..\HARDWARE\PWM;..\HARDWARE\RNG;..\FATFS\source;..\FATFS\exfuns;..\FATFS\src;..\CHINESE;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\MALLOC;..\GUI;..\GUI\lvgl_driver;..\GUI\lvgl_src;..\GUI\lvgl_template_src;..\GUI_APP;..\WIFI;..\IOT_PROTOCOL\IOT_TOOLS;..\IOT_PROTOCOL;..\HARDWARE\RELAY;..\HARDWARE\DMA;..\GUI_APP\images;..\GUI_APP\guider_fonts;..\GUI_APP\guider_customer_fonts;..\GUI\lvgl_src\lv_font;..\GUI\lvgl_src\lv_widgets
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c stm32f4xx_hal_msp.c transaction.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/TOUCH/: touch.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/DS18B20/: ds18b20.c
    ../HARDWARE/HCSR04/: hcsr04.c
    ../HARDWARE/PWM/: pwm.c rgb.c
    ../HARDWARE/RNG/: rng.c
    ../HARDWARE/KEY/: key.c hal_key.c
    ../HARDWARE/RELAY/: relay.c
    ../HARDWARE/DMA/: dma.c
  group MALLOC
    ../MALLOC/: malloc.c
  group FATFS
    ../FATFS/source/: diskio.c ff.c ffsystem.c ffunicode.c
    ../FATFS/exfuns/: exfuns.c fattester.c
  group CHINESE
    ../CHINESE/: fontupd.c text.c
  group FreeRTOS_CODE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group GUI
    ../GUI/lvgl_src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    ../GUI/lvgl_src/lv_draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../GUI/lvgl_src/lv_font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_16.c lv_font_montserrat_24.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c
    ../GUI/lvgl_src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../GUI/lvgl_src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_debug.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_templ.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../GUI/lvgl_src/lv_themes/: lv_theme.c lv_theme_empty.c lv_theme_material.c lv_theme_mono.c lv_theme_template.c
    ../GUI/lvgl_src/lv_widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_calendar.c lv_canvas.c lv_chart.c lv_checkbox.c lv_cont.c lv_cpicker.c lv_dropdown.c lv_gauge.c lv_img.c lv_imgbtn.c lv_keyboard.c lv_label.c lv_led.c lv_line.c lv_linemeter.c lv_list.c lv_msgbox.c lv_objmask.c lv_objx_templ.c lv_page.c lv_roller.c lv_slider.c lv_spinbox.c lv_spinner.c lv_switch.c lv_table.c lv_tabview.c lv_textarea.c lv_tileview.c lv_win.c
    ../GUI/lvgl_driver/: lv_port_disp.c lv_port_indev.c
  group GUI_APP
    ../GUI_APP/: events_init.c gui_guider.c setup_scr_screen.c
    ../GUI_APP/guider_fonts/: lv_font_montserratMedium_12.c
    ../GUI_APP/images/: _user_login_logo_alpha_100x60.c _wifi_alpha_30x25.c _wifi1_alpha_30x25.c
  group IOT_PROTOCOL
    ../IOT_PROTOCOL/: gizwits_product.c gizwits_protocol.c
  group IOT_TOOLS
    ../IOT_PROTOCOL/IOT_TOOLS/: common.c dataPointTools.c ringbuffer.c
  group HALLIB
    ../HALLIB/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma.c stm32f4xx_hal_spi.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sd.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sram.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rng.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm4.h mpu_armv7.h startup_stm32f407xx.s
  group README
    ../: read.txt
